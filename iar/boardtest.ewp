# IAR project boardtest.ewp, settings and files
configuration K64FX_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64xX512xxx12 Freescale MK64xX512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK64F12; MK64FX12
  ICCARM.CCIncludePath2: ..\app; ..\app\inc; ..\Driver; ..\Lib\Driver; ..\Lib\Chip\inc; ..\Lib\Chip\inc\IAR; ..\Lib\Chip\inc\kinetis; ..\Lib\CMSIS\inc; ..\Lib\Board\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: camera.srec
  ILINK.IlinkOutputFile: mydemo.out
  ILINK.IlinkIcfFile: ..\Lib\icf_files\K64FX_512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration K60DN_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  OBJCOPY.OOCOutputFile: boardtest.srec
  ILINK.IlinkIcfFile: ..\Lib\icf_files\128KB_Pflash.icf
  group app
    ../app/: main.c
  group Driver
    ../Driver/: button.c button.h include.h led.c led.h oled12864.c oled12864.h pid.c
  group lib
    ../Lib/Chip/src/: MK60_adc.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c
  group system
    ../Lib/Chip/inc/: common.h
    ../app/inc/: include.h MK60_conf.h PORT_cfg.h
    ../Lib/Chip/src/: misc.c vectors.c
    ../app/: MK60_conf.c
    ../Lib/Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
